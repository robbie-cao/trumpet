# IAR project DPWM.ewp, settings and files
configuration DPWM (ARM, debug)
  General.OGChipSelectEditMenu: ISD9160LF3AN Nuvoton ISD9160LF3AN
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\ISD9100\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: DPWM.icf
  ILINK.IlinkExtraOptions: --image_input=..\Audio.bin,u32audioBegin,BIN_START,4; --image_input=..\Audio_End.bin,u32audioEnd,BIN_END,4
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../Library/Device/Nuvoton/ISD9100/Source/IAR/: startup_ISD9100.s
    ../../../../Library/Device/Nuvoton/ISD9100/Source/: system_ISD9100.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c dpwm.c pdma.c retarget.c sys.c uart.c
  group User
    ../: main.c
