# IAR project CapSense.ewp, settings and files
configuration CapSense (ARM, debug)
  General.OGChipSelectEditMenu: ISD9160LF3AN Nuvoton ISD9160LF3AN
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG_ENABLE_SEMIHOST
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\ISD9100\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../Library/Device/Nuvoton/ISD9100/Source/IAR/: startup_ISD9100.s
    ../../../../Library/Device/Nuvoton/ISD9100/Source/: system_ISD9100.c
  group Library
    ../../../../Library/StdDriver/src/: capsense.c clk.c gpio.c retarget.c sys.c
  group User
    ../: main.c TouchPad.c
