# IAR project fmc_rw.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ISD9160LF3AN Nuvoton ISD9160LF3AN
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\ISD9100\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: ISD9160LF3AN Nuvoton ISD91xx series (ISD9160LF3AN)
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../../../../Library/Device/Nuvoton/ISD9100/Source/IAR/: startup_ISD9100.s
    ../../../../Library/Device/Nuvoton/ISD9100/Source/: system_ISD9100.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c uart.c
  group User
    ../: main.c
