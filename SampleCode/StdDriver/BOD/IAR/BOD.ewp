# IAR project BOD.ewp, settings and files
configuration BOD (ARM, debug)
  General.OGChipSelectEditMenu: ISD9160LF3AN Nuvoton ISD9160LF3AN
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\ISD9100\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: ADC.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../Library/Device/Nuvoton/ISD9100/Source/IAR/: startup_ISD9100.s
    ../../../../Library/Device/Nuvoton/ISD9100/Source/: system_ISD9100.c
  group Library
    ../../../../Library/StdDriver/src/: adc.c biq.c bod.c clk.c dpwm.c fmc.c gpio.c retarget.c sys.c uart.c
  group User
    ../: main.c
