# Keil uVision project MatrixKey.uvproj, settings and files
target MatrixKey (ARM-ADS)
  device: ISD9160 Nuvoton
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x233FF) CLOCK(49152000) CPUTYPE("Cortex-M0")
  output: MatrixKey
  AfterMake: fromelf --bincombined --output "$L@L.bin" "$L@L.axf"
  AfterMake: "C:\Nuvoton NuVoice Tool\Utility\PadFile.exe" --size=0x23400 --pad=0xff  "$L@L.bin"
  c flags: OneElfS=1 wLevel=2
  c define: __ISD9100__,DEBUG_ENABLE_SEMIHOST
  c include: .;..\..\..\..\Library\Device\Nuvoton\ISD9100\Include;..\..\..\..\Library\Framework\inc;..\..\..\..\Library\IO\inc;..\..\..\..\Library\Audio\inc;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Storage\inc;..\..\..\..\Library\CMSIS\Include;..\
  asm define: __ISD9100__
  memory RVCT4: ROM 0x0 size 0x23400
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: .\Application_Keil.ld
  link misc: --pd="-DSRAM_SIZE=0x1000" --pd="-DROM_SIZE=0x7ff0"  --map --datacompressor=off --info=inline --entry Reset_Handler --remove
  group Source
    ../: main.c InputKeyActions.c InterruptHandler.c
  group Include
    ../: ConfigApp.h ConfigIO.h ConfigIP.h ConfigSysClk.h
  group CMSIS
    ../../../../Library/Device/Nuvoton/ISD9100/Source/: system_ISD9100.c
    ./: startup_ISD9100.s
  group Framework
    ../../../../Library/Framework/src/: ConfigIO.c SysClk.c
  group IO
    ../../../../Library/IO/src/: Keypad.c
  group Driver
    ../../../../Library/StdDriver/src/: sys.c retarget.c clk.c gpio.c timer.c adc.c rtc.c spi.c wdt.c acmp.c biq.c bod.c capsense.c CRC.c dpwm.c fmc.c i2c.c i2s.c pdma.c pwm.c talarm.c uart.c
