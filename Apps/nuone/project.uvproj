# Keil uVision project project.uvproj, settings and files
target nuone (ARM-ADS)
  device: ISD9160 Nuvoton
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x233FF) CLOCK(49152000) CPUTYPE("Cortex-M0")
  output: nuone
  AfterMake: fromelf --bincombined --output "$L@L.bin" "$L@L.axf"
  AfterMake: "C:\Nuvoton NuVoice Tool\Utility\PadFile.exe" --size=0x23400 --pad=0xff  "$L@L.bin"
  c flags: Optim=1 OneElfS=1
  c define: __ISD9100__ xDEBUG_ENABLE_SEMIHOST LOG_LEVEL_DEBUG
  c include: .;..\..\BSP\Library\Device\Nuvoton\ISD9100\Include;..\..\BSP\Library\Framework\inc;..\..\BSP\Library\IO\inc;..\..\BSP\Library\Audio\inc;..\..\BSP\Library\StdDriver\inc;..\..\BSP\Library\Storage\inc;..\..\BSP\Library\CMSIS\Include;..\..\Common;..\..\Driver;..\..\Utils
  asm define: __ISD9100__
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x23400
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: .\Application_Keil.ld
  link misc: --pd="-DSRAM_SIZE=0x3000" --pd="-DROM_SIZE=0x23400"  --map --datacompressor=off --info=inline --entry Reset_Handler --remove
  group Source
    ./: main.c AppFunctions.c AppCallback.c InputKeyActions.c InterruptHandler.c Powerdown.c
  group Include
    ./: SPIFlashMap.h App.h ConfigApp.h ConfigSysClk.h ConfigUltraIO.h ConfigIO.h ConfigIP.h InState.h
  group CMSIS
    ../../BSP/Library/Device/Nuvoton/ISD9100/Source/: system_ISD9100.c
    ./: startup_ISD9100.s
  group NuOneExApp
    ./: NuOneExApp_Decode.c NuOneExApp_Decode.h
  group Framework
    ../../BSP/Library/Framework/src/: AudioMixer.c AudioRom.c BufCtrl.c ConfigIO.c MicSpk.c Playback.c SPIFlashUtil.c UltraIO.c SysClk.c PdmaCtrl.c
  group Storage
    ../../BSP/Library/Storage/src/: SPIFlash.c
  group IO
    ../../BSP/Library/IO/src/: Keypad.c
  group StdDriver
    ../../BSP/Library/StdDriver/src/: acmp.c adc.c biq.c bod.c capsense.c clk.c CRC.c dpwm.c fmc.c gpio.c i2c.c i2s.c pdma.c pwm.c retarget.c rtc.c spi.c sys.c talarm.c timer.c uart.c wdt.c
  group Library
    ../../BSP/Library/Audio/arm/: ImaAdpcm_Keil.lib LP8_Keil.lib MD4_Keil.lib NuLiteEx_Keil.lib NuOneEx_Keil.lib NuSoundEx_Keil.lib NuVoxEx_Keil.lib P16_Keil.lib
  group Driver
    ../../Driver/: DrvUart.c
  group Utils
    ../../Utils/: Parser.c ATC.c
