# Keil uVision project project.uvproj, settings and files
target hello (ARM-ADS)
  device: ISD9160 Nuvoton
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x233FF) CLOCK(49152000) CPUTYPE("Cortex-M0")
  output: hello
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1
  c define: xDEBUG_ENABLE_SEMIHOST LOG_LEVEL_DEBUG
  c include: ..\..\BSP\Library\CMSIS\Include;..\..\BSP\Library\Device\Nuvoton\ISD9100\Include;..\..\BSP\Library\StdDriver\inc;..\..\Common;..\..\Driver;..\..\Utils
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x23400
  memory RVCT9: RAM 0x20000000 size 0x3000
  link misc: --map --first='startup_ISD9100.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ./: startup_ISD9100.s
    ../../BSP/Library/Device/Nuvoton/ISD9100/Source/: system_ISD9100.c
  group User
    ./: main.c
  group Library
    ../../BSP/Library/StdDriver/src/: uart.c clk.c retarget.c sys.c
  group Driver
    ../../Driver/: DrvUart.c
  group Utils
    ../../Utils/: Parser.c ATC.c
