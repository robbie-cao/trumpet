# IAR project I2S_NAU8822.ewp, settings and files
configuration I2S_NAU8822 (ARM, debug)
  General.OGChipSelectEditMenu: ISD9160LF3AN Nuvoton ISD9160LF3AN
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\ISD9100\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../Library/Device/Nuvoton/ISD9100/Source/IAR/: startup_ISD9100.s
    ../../../../Library/Device/Nuvoton/ISD9100/Source/: system_ISD9100.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c i2c.c i2s.c retarget.c sys.c uart.c
  group User
    ../: ISD9100_isr.c main.c
