# Keil uVision project SPI_Master_PDMA.uvproj, settings and files
target SPI_Master_PDMA (ARM-ADS)
  device: ISD9160 Nuvoton
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x233FF) CLOCK(49152000) CPUTYPE("Cortex-M0")
  output: SPI_Master_PDMA
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1
  c define: DEBUG_ENABLE_SEMIHOST
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\ISD9100\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x23400
  memory RVCT9: RAM 0x20000000 size 0x3000
  link misc: --map --first='startup_ISD9100.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/ISD9100/Source/: system_ISD9100.c
    ./: startup_ISD9100.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: uart.c clk.c retarget.c spi.c sys.c pdma.c
