# Keil uVision project SPIFlash.uvproj, settings and files
target SPIFlash (ARM-ADS)
  device: ISD9160 Nuvoton
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x233FF) CLOCK(49152000) CPUTYPE("Cortex-M0")
  output: SPIFlash
  AfterMake: fromelf --bincombined --output "$L@L.bin" "$L@L.axf"
  AfterMake: "C:\Nuvoton NuVoice Tool\Utility\PadFile.exe" --size=0x23400 --pad=0xff  "$L@L.bin"
  c flags: Optim=1 OneElfS=1
  c define: __ISD9100__,DEBUG_ENABLE_SEMIHOST
  c include: .;..\..\..\..\Library\Device\Nuvoton\ISD9100\Include;..\..\..\..\Library\Framework\inc;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Storage\inc;..\..\..\..\Library\CMSIS\Include
  asm define: __ISD9100__
  memory RVCT4: ROM 0x0 size 0x23400
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: .\Application_Keil.ld
  link misc: --pd="-DSRAM_SIZE=0x3000" --pd="-DROM_SIZE=0x23400" --map --datacompressor=off --info=inline --entry Reset_Handler --remove
  group Source
    ../: main.c
  group Include
    ../: ConfigSysClk.h
  group CMSIS
    ../../../../Library/Device/Nuvoton/ISD9100/Source/: system_ISD9100.c
    ./: startup_ISD9100.s
  group Framework
    ../../../../Library/Framework/src/: SysClk.c
  group Storage
    ../../../../Library/Storage/src/: SPIFlash.c
  group Driver
    ../../../../Library/StdDriver/src/: acmp.c adc.c biq.c bod.c capsense.c clk.c CRC.c dpwm.c fmc.c gpio.c i2c.c i2s.c pdma.c pwm.c retarget.c rtc.c spi.c sys.c talarm.c timer.c uart.c wdt.c
